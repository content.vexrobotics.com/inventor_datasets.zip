# Autodesk Inventor part: BEARING-RIVET
## iProperties
Created: 2007-12
Part Number: BEARING-RIVET
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
