# Autodesk Inventor assembly: Bevel_Gear
## iProperties
Created: 2008-03
Part Number: Bevel_Gear
Document SubType Name: Assembly
