# Autodesk Inventor assembly: LIMIT-SWITCH
## iProperties
Created: 2008-05
Document SubType Name: Assembly
