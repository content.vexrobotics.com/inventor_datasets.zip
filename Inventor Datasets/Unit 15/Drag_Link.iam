# Autodesk Inventor assembly: Drag_Link
## iProperties
Created: 2008-04
Part Number: Drag_Link
Document SubType Name: Assembly
