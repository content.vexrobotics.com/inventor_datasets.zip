# Autodesk Inventor assembly: CLUTCH
## iProperties
Created: 2007-08
Part Number: CLUTCH
Document SubType Name: Assembly
