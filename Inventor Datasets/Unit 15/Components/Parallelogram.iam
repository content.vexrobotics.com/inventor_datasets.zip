# Autodesk Inventor assembly: Parallelogram
## iProperties
Created: 2008-04
Part Number: Parallelogram
Document SubType Name: Assembly
