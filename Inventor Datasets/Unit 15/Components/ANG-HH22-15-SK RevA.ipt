# Autodesk Inventor part: ANG-HH22-15-SK RevA
## iProperties
Created: 2007-12
Part Number: ANG-HH22-15-SK RevA
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
