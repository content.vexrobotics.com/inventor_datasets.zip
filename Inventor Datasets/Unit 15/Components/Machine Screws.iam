# Autodesk Inventor assembly: Machine Screws
## iProperties
Created: 2008-03
Part Number: Machine Screws
Document SubType Name: Assembly
