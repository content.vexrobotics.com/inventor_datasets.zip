# Autodesk Inventor part: VL-BAR-10
## iProperties
Created: 2005-08
Part Number: VL-BAR-10
Document SubType Name: Sheet Metal
Density: 1 g/cm^3
## Feature names
1. Rectangular Pattern1
2. Plate1
