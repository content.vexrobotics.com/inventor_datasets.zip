# Autodesk Inventor part: LongBar
## iProperties
Created: 2005-08
Part Number: LongBar
Document SubType Name: Sheet Metal
Density: 1 g/cm^3
## Feature names
1. Rectangular Pattern1
2. Plate1
