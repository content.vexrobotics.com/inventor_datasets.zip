# Autodesk Inventor assembly: Double_Rocker
## iProperties
Created: 2008-04
Part Number: Double_Rocker
Document SubType Name: Assembly
