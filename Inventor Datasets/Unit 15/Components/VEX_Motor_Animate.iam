# Autodesk Inventor assembly: VEX-MOTOR
## iProperties
Created: 2007-08
Part Number: VEX-MOTOR
Document SubType Name: Assembly
