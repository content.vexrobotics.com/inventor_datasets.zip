# Autodesk Inventor part: SHAFT-2000
## iProperties
Created: 2007-08
Part Number: SHAFT-2000
Material: Stainless Steel
Document SubType Name: Modeling
Density: 8.08 g/cm^3
## Feature names
1. Base1
