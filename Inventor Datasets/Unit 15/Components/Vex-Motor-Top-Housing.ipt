# Autodesk Inventor part: Vex-Motor-Top-Housing
## iProperties
Part Number: Vex-Motor-Top-Housing
Material: Alloy Steel
Document SubType Name: Modeling
Density: 7.85 g/cm^3
## Feature names
1. Base1
