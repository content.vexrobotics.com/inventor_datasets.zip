# Autodesk Inventor part: Support
## iProperties
Created: 2008-04
Part Number: Support
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Extrusion1
2. Extrusion2
