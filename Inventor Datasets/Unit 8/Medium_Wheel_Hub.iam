# Autodesk Inventor assembly: Medium_Wheel_Hub
## iProperties
Created: 2008-03
Part Number: Medium_Wheel_Hub
Document SubType Name: Assembly
