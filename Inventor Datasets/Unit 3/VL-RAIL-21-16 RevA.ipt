# Autodesk Inventor part: VL-RAIL-21-16 RevA
## iProperties
Created: 2007-10
Part Number: VL-RAIL-21-16 RevA
Material: Steel
Document SubType Name: Modeling
Density: 7.85 g/cm^3
