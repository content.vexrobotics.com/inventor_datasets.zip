# Autodesk Inventor part: ANTENNA-TUBE
## iProperties
Created: 2007-08
Part Number: ANTENNA-TUBE
Material: Lexan, Clear
Document SubType Name: Modeling
Density: 1.2 g/cm^3
## Feature names
1. Base1
