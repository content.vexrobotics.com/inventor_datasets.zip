# Autodesk Inventor part: MEDIUM-WHEEL-TIRE
## iProperties
Created: 2007-08
Part Number: MEDIUM-WHEEL-TIRE
Material: Rubber
Document SubType Name: Modeling
Density: 0.93 g/cm^3
