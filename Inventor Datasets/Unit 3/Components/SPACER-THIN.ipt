# Autodesk Inventor part: SPACER-THIN
## iProperties
Created: 2007-08
Part Number: SPACER-THIN
Material: Delrin, Black
Document SubType Name: Modeling
Density: 1.425 g/cm^3
## Feature names
1. Base1
