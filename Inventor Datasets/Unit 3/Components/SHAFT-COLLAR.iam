# Autodesk Inventor assembly: SHAFT-COLLAR
## iProperties
Created: 2007-08
Part Number: SHAFT-COLLAR
Document SubType Name: Assembly
