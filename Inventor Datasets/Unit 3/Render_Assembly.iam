# Autodesk Inventor assembly: Render_Assembly
## iProperties
Created: 2007-12
Part Number: Render_Assembly
Document SubType Name: Assembly
