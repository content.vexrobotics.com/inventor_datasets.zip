# Autodesk Inventor part: MEDIUM-WHEEL-TIRE_MIR
## iProperties
Created: 2007-08
Part Number: MEDIUM-WHEEL-TIRE_MIR
Material: Rubber
Document SubType Name: Modeling
Density: 0.93 g/cm^3
