# Autodesk Inventor part: Part3
## iProperties
Created: 2008-05
Part Number: Part3
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Extrusion1
