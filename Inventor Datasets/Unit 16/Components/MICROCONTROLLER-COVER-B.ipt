# Autodesk Inventor part: MICROCONTROLLER-COVER-B
## iProperties
Created: 2008-01
Part Number: MICROCONTROLLER-COVER-B
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
