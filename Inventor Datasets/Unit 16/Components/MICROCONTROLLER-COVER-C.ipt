# Autodesk Inventor part: MICROCONTROLLER-COVER-C
## iProperties
Created: 2008-01
Part Number: MICROCONTROLLER-COVER-C
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
