# Autodesk Inventor assembly: VEX-MEDIUM-WHEEL
## iProperties
Created: 2007-08
Part Number: VEX-MEDIUM-WHEEL
Document SubType Name: Assembly
