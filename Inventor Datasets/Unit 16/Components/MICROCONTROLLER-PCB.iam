# Autodesk Inventor assembly: MICROCONTROLLER-PCB
## iProperties
Created: 2007-09
Part Number: MICROCONTROLLER-PCB
Document SubType Name: Assembly
