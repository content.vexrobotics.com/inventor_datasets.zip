# Autodesk Inventor assembly: Shaft_Collar_MIR2
## iProperties
Created: 2008-03
Part Number: Shaft_Collar_MIR2
Document SubType Name: Assembly
