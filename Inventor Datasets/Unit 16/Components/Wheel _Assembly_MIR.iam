# Autodesk Inventor assembly: Wheel _Assembly_MIR
## iProperties
Created: 2007-12
Part Number: Wheel _Assembly_MIR
Document SubType Name: Assembly
