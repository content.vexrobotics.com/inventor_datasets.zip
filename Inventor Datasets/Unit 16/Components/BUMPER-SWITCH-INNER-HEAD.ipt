# Autodesk Inventor part: BUMPER-SWITCH-INNER-HEAD
## iProperties
Created: 2007-08
Part Number: BUMPER-SWITCH-INNER-HEAD
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
