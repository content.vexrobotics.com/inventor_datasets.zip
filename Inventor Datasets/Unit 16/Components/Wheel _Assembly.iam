# Autodesk Inventor assembly: Wheel _Assembly
## iProperties
Created: 2007-12
Part Number: Wheel _Assembly
Document SubType Name: Assembly
