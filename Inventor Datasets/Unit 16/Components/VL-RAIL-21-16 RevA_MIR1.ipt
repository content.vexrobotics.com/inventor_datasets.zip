# Autodesk Inventor part: VL-RAIL-21-16 RevA_MIR1
## iProperties
Created: 2007-10
Part Number: VL-RAIL-21-16 RevA_MIR1
Material: Steel
Document SubType Name: Modeling
Density: 7.85 g/cm^3
