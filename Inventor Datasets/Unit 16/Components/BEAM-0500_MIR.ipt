# Autodesk Inventor part: BEAM-0500_MIR
## iProperties
Created: 2008-05
Part Number: BEAM-0500_MIR
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Derived Body1 [Tagging]
