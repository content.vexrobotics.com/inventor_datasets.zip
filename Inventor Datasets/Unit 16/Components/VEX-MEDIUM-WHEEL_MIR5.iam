# Autodesk Inventor assembly: VEX-MEDIUM-WHEEL_MIR5
## iProperties
Created: 2007-08
Part Number: VEX-MEDIUM-WHEEL_MIR5
Document SubType Name: Assembly
