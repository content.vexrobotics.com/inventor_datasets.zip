# Autodesk Inventor assembly: BUMPER-SWITCH
## iProperties
Created: 2007-08
Part Number: BUMPER-SWITCH
Document SubType Name: Assembly
