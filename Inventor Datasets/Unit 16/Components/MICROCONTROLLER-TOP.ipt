# Autodesk Inventor part: MICROCONTROLLER-TOP
## iProperties
Created: 2007-09
Part Number: MICROCONTROLLER-TOP
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
