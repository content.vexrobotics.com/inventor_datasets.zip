# Autodesk Inventor part: MICROCONTROLLER-BOT
## iProperties
Created: 2007-09
Part Number: MICROCONTROLLER-BOT
Document SubType Name: Modeling
Density: 1 g/cm^3
