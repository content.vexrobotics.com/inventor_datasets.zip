# Autodesk Inventor assembly: VEX-MEDIUM-WHEEL_MIR1
## iProperties
Created: 2007-08
Part Number: VEX-MEDIUM-WHEEL_MIR1
Document SubType Name: Assembly
