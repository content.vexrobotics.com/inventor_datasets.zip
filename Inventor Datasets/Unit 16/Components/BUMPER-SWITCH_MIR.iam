# Autodesk Inventor assembly: BUMPER-SWITCH_MIR
## iProperties
Created: 2007-08
Part Number: BUMPER-SWITCH_MIR
Document SubType Name: Assembly
