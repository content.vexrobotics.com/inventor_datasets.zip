# Autodesk Inventor assembly: MicroController View
## iProperties
Created: 2007-09
Part Number: MicroController View
Document SubType Name: Assembly
