# Autodesk Inventor part: MICROCONTROLLER-SWITCH
## iProperties
Created: 2007-09
Part Number: MICROCONTROLLER-SWITCH
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
