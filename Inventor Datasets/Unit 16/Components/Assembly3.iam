# Autodesk Inventor assembly: Assembly3
## iProperties
Created: 2008-05
Part Number: Assembly3
Document SubType Name: Assembly
