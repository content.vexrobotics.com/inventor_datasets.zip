# Autodesk Inventor assembly: VEX-MEDIUM-WHEEL_MIR
## iProperties
Created: 2007-08
Part Number: VEX-MEDIUM-WHEEL_MIR
Document SubType Name: Assembly
