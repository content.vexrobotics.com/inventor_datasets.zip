# Autodesk Inventor part: Connector01
## iProperties
Created: 2008-05
Part Number: Connector01
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
