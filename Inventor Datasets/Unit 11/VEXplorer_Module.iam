# Autodesk Inventor assembly: Vexplorer_Module_Backup
## iProperties
Created: 2007-10
Part Number: Vexplorer_Module_Backup
Document SubType Name: Assembly
