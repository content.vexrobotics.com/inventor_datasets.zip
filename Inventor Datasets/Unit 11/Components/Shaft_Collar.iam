# Autodesk Inventor assembly: Shaft_Collar
## iProperties
Created: 2008-03
Part Number: Shaft_Collar
Document SubType Name: Assembly
