# Autodesk Inventor part: SHAFT-2000
## iProperties
Created: 2007-10
Part Number: SHAFT-2000
Document SubType Name: Modeling
Material: Steel
Density: 7.85 g/cm^3
## Feature names
1. Base1
