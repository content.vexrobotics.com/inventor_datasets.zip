# Autodesk Inventor assembly: NUT-832-KEPS
## iProperties
Created: 2007-09
Part Number: NUT-832-KEPS
Document SubType Name: Assembly
