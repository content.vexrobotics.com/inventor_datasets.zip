# Autodesk Inventor assembly: IDLER-WHEEL
## iProperties
Created: 2007-09
Part Number: IDLER-WHEEL
Document SubType Name: Assembly
