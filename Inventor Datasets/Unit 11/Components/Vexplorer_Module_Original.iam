# Autodesk Inventor assembly: Vexplorer-Module-Assy
## iProperties
Created: 2007-10
Part Number: Vexplorer-Module-Assy
Document SubType Name: Assembly
