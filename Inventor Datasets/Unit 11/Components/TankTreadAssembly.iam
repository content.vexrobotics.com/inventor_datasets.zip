# Autodesk Inventor assembly: TankTreadAssembly
## iProperties
Created: 2008-04
Part Number: TankTreadAssembly
Document SubType Name: Assembly
