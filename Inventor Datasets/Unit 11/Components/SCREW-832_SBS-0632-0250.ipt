# Autodesk Inventor part: SCREW-832_SBS-0632-0250
## iProperties
Created: 2007-10
Part Number: SCREW-832_SBS-0632-0250
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
