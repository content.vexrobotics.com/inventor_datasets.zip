# Autodesk Inventor part: IDLER-WHEEL-ROLLER
## iProperties
Created: 2007-09
Part Number: IDLER-WHEEL-ROLLER
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
