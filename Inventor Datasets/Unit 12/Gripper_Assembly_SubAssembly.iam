# Autodesk Inventor assembly: Gripper_Assembly_SubAssembly
## iProperties
Created: 2007-10
Part Number: Gripper_Assembly_SubAssembly
Document SubType Name: Assembly
