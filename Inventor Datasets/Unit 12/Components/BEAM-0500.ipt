# Autodesk Inventor part: BEAM-0500
## iProperties
Created: 2007-10
Part Number: BEAM-0500
Document SubType Name: Modeling
Material: Aluminum-6061
Density: 2.71 g/cm^3
## Feature names
1. Base1
