# Autodesk Inventor assembly: Vexplorer-CLAW-FINGER-ASSY
## iProperties
Created: 2007-10
Part Number: Vexplorer-CLAW-FINGER-ASSY
Document SubType Name: Assembly
