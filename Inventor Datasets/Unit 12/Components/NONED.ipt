# Autodesk Inventor part: NONED
## iProperties
Created: 2007-10
Part Number: NONED
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
