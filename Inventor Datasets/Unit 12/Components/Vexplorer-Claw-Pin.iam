# Autodesk Inventor assembly: Vexplorer-Claw-Pin
## iProperties
Created: 2007-10
Part Number: Vexplorer-Claw-Pin
Document SubType Name: Assembly
