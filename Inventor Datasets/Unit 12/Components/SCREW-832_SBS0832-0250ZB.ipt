# Autodesk Inventor part: SCREW-832_SBS0832-0250ZB
## iProperties
Created: 2007-10
Part Number: SCREW-832_SBS0832-0250ZB
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
