# Autodesk Inventor part: Base_02
## iProperties
Created: 2008-06
Part Number: Base_02
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Extrusion1
