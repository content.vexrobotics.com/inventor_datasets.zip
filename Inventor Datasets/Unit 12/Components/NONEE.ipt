# Autodesk Inventor part: NONEE
## iProperties
Created: 2007-10
Part Number: NONEE
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
