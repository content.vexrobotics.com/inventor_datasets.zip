# Autodesk Inventor assembly: Gripper_Assembly
## iProperties
Created: 2007-10
Part Number: Gripper_Assembly
Document SubType Name: Assembly
