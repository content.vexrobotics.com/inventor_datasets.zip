# Autodesk Inventor assembly: Rack_Assembly
## iProperties
Created: 2007-09
Part Number: Rack_Assembly
Document SubType Name: Assembly
