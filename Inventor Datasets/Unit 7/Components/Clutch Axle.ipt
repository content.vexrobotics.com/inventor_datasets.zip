# Autodesk Inventor part: Clutch Axle
## iProperties
Created: 2007-08
Part Number: Clutch Axle
Material: Steel
Document SubType Name: Modeling
Density: 7.85 g/cm^3
## Feature names
1. Base1
