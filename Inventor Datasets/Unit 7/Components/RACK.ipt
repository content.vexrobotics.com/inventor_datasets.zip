# Autodesk Inventor part: RACK
## iProperties
Created: 2007-09
Part Number: RACK
Material: ABS Plastic
Document SubType Name: Modeling
Density: 1.06 g/cm^3
## Feature names
1. Base1
