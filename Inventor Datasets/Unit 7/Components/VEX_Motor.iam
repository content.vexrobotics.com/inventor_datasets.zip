# Autodesk Inventor assembly: VEX_Motor
## iProperties
Created: 2007-08
Part Number: VEX_Motor
Document SubType Name: Assembly
