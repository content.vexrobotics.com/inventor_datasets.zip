# Autodesk Inventor assembly: LINEAR-SLIDE
## iProperties
Created: 2007-09
Part Number: LINEAR-SLIDE
Document SubType Name: Assembly
