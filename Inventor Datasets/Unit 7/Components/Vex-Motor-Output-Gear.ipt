# Autodesk Inventor part: Vex-Motor-Output-Gear
## iProperties
Created: 2007-08
Part Number: Vex-Motor-Output-Gear
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
