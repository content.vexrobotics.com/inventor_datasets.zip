# Autodesk Inventor assembly: Shaft_Collar
## iProperties
Created: 2008-04
Part Number: Shaft_Collar
Document SubType Name: Assembly
