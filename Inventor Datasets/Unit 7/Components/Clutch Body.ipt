# Autodesk Inventor part: Clutch Body
## iProperties
Created: 2007-08
Part Number: Clutch Body
Material: ABS Plastic
Document SubType Name: Modeling
Density: 1.06 g/cm^3
## Feature names
1. Base1
