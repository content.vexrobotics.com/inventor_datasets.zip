# Autodesk Inventor assembly: Rack_Pinion
## iProperties
Created: 2008-04
Part Number: Rack_Pinion
Document SubType Name: Assembly
