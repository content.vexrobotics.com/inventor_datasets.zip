# Autodesk Inventor part: Vex-Wire-Support
## iProperties
Created: 2007-08
Part Number: Vex-Wire-Support
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
