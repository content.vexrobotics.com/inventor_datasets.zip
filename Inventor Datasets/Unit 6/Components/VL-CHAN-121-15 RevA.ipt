# Autodesk Inventor part: VL-CHAN-121-15 RevA
## iProperties
Created: 2007-12
Part Number: VL-CHAN-121-15 RevA
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
