# Autodesk Inventor part: BEAM-2000
## iProperties
Created: 2007-08
Part Number: BEAM-2000
Material: Aluminum-6061
Document SubType Name: Modeling
Density: 2.71 g/cm^3
## Feature names
1. Base1
