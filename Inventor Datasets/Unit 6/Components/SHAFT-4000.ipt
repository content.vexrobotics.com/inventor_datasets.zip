# Autodesk Inventor part: SHAFT-4000
## iProperties
Created: 2007-12
Part Number: SHAFT-4000
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
