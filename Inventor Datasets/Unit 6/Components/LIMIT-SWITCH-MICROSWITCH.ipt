# Autodesk Inventor part: LIMIT-SWITCH-MICROSWITCH
## iProperties
Created: 2007-08
Part Number: LIMIT-SWITCH-MICROSWITCH
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
