# Autodesk Inventor assembly: VEX-SMALL-WHEEL
## iProperties
Created: 2007-08
Part Number: VEX-SMALL-WHEEL
Document SubType Name: Assembly
