# Autodesk Inventor part: VL-BAR-25-bent
## iProperties
Created: 2007-12
Part Number: VL-BAR-25-bent
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
