# Autodesk Inventor part: VEX-84-TOOTH-GEAR
## iProperties
Created: 2007-12
Part Number: VEX-84-TOOTH-GEAR
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
