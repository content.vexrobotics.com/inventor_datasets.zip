# Autodesk Inventor part: SMALL-WHEEL-HUB
## iProperties
Created: 2007-08
Part Number: SMALL-WHEEL-HUB
Material: ABS Plastic
Document SubType Name: Modeling
Density: 1.06 g/cm^3
