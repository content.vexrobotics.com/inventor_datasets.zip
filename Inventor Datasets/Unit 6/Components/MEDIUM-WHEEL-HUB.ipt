# Autodesk Inventor part: MEDIUM-WHEEL-HUB
## iProperties
Created: 2007-08
Part Number: MEDIUM-WHEEL-HUB
Material: ABS Plastic
Document SubType Name: Modeling
Density: 1.06 g/cm^3
