# Autodesk Inventor part: VL-CHAN-121-25 RevA
## iProperties
Created: 2007-12
Part Number: VL-CHAN-121-25 RevA
Document SubType Name: Modeling
Density: 1 g/cm^3
