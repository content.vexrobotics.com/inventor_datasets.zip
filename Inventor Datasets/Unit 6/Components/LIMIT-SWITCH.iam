# Autodesk Inventor assembly: LIMIT-SWITCH
## iProperties
Created: 2007-12
Part Number: LIMIT-SWITCH
Document SubType Name: Assembly
