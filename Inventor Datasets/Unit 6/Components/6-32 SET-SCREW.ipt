# Autodesk Inventor part: 6-32 SET-SCREW
## iProperties
Created: 2007-08
Part Number: 6-32 SET-SCREW
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
