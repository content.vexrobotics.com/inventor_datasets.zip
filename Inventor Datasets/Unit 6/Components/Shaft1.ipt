# Autodesk Inventor part: Shaft1
## iProperties
Created: 2007-12
Part Number: Shaft1
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Extrusion1
2. Extrusion2
