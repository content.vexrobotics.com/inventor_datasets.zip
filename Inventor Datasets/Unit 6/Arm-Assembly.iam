# Autodesk Inventor assembly: Arm-Assembly
## iProperties
Created: 2007-12
Part Number: Arm-Assembly
Document SubType Name: Assembly
