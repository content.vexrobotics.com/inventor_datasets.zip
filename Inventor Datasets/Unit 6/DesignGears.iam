# Autodesk Inventor assembly: DesignGears
## iProperties
Created: 2007-12
Part Number: DesignGears
Document SubType Name: Assembly
