# Autodesk Inventor part: MICROCONTROLLER-COVER-A
## iProperties
Created: 2008-01
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
