# Autodesk Inventor assembly: MicroController View
## iProperties
Created: 2008-06
Part Number: MicroController View
Document SubType Name: Assembly
Title: MicroController View
