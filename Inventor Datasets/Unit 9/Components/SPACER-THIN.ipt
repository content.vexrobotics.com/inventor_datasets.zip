# Autodesk Inventor part: SPACER-THIN
## iProperties
Created: 2008-05
Part Number: SPACER-THIN
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
