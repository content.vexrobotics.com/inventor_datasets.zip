# Autodesk Inventor assembly: Worm_Gear
## iProperties
Created: 2008-05
Part Number: Worm_Gear
Document SubType Name: Assembly
