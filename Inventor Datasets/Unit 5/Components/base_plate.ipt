# Autodesk Inventor part: base_plate
## iProperties
Created: 2008-06
Part Number: base_plate
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Extrusion1
2. Hole1
3. Fillet1
