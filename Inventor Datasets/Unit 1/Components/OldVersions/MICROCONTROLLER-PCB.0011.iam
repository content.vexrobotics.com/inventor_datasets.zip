# Autodesk Inventor assembly: MICROCONTROLLER-PCB.0011
## iProperties
Created: 2008-06
Document SubType Name: Assembly
