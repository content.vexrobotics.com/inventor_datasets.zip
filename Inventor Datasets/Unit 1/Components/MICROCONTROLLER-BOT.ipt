# Autodesk Inventor part: MICROCONTROLLER-BOT
## iProperties
Created: 2008-06
Document SubType Name: Modeling
Density: 1 g/cm^3
