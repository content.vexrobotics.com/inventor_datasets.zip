# Autodesk Inventor part: MICROCONTROLLER-FRONT
## iProperties
Created: 2008-06
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
