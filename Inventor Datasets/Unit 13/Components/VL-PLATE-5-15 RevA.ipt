# Autodesk Inventor part: VL-PLATE-5-15 RevA
## iProperties
Created: 2008-05
Part Number: VL-PLATE-5-15 RevA
Document SubType Name: Modeling
Density: 1 g/cm^3
## Feature names
1. Base1
