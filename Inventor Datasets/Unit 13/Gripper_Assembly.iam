# Autodesk Inventor assembly: Gripper_Assembly
## iProperties
Created: 2008-05
Part Number: Gripper_Assembly
Document SubType Name: Assembly
